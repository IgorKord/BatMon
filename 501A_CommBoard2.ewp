# IAR project 501A_CommBoard2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x180
  General.SCRStackSize: 32
  General.RTConfigPath: DLib_Config_Normal.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m644 ATmega644
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  postbuild: copy .\List\*.map .\Exe\
  XLINK.XclFile: $TOOLKIT_DIR$/src/template/cfgm644.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    SourceCode/: ASCII_commands.c ASCII_commands.h DNP.c Front_menu.c GLOBALS.H Hardware.h main.c Structure_defs.h
    ./: Code_Comments.txt
